# Keil uVision project ModulesIfGen.uvproj, settings and files
target ModulesIfGen (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ModulesIfGen
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;..\ModulesIfGen
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ModulesIfGen.cpp
    ./common/: Logger.cpp Logger.h commonTypes.h
    ./Interfaces/: IRunnable.h VirtualBusTypes.h VirtualBus.h VirtualBus.cpp VirtualBus_ModuleA.h VirtualBus_ModuleB.h VirtualBus_ModuleC.h
    ./IO/: PLL.c PLL.h UART.c UART.h UartAdapter.cpp UartAdapter.h
    ./ModuleA/: ModuleA.cpp ModuleA.h
    ./ModuleB/: ModuleB.cpp ModuleB.h
    ./ModuleC/: ModuleC.cpp ModuleC.h
  group config
    ./config/: module_files.csv module_array_members.csv module_vars.csv

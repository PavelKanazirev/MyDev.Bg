# Keil uVision project ModulesPolymorph.uvproj, settings and files
target ModulesIf_Run (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ModulesIf_Run +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: startup.s ModulesIf_Run.cpp
  group IO
    ./: UartAdapter.cpp UART.c PLL.c
  group common
    ./common/: Logger.cpp Logger.h
  group Modules
    ./ModuleA/: ModuleA.cpp ModuleA.h
    ./ModuleB/: ModuleB.cpp ModuleB.h
    ./ModuleC/: ModuleC.cpp ModuleC.h
  group Interfaces
    ./Interfaces/: IRunnable.h

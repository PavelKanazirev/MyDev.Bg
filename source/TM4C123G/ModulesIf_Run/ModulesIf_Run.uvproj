# Keil uVision project ModulesIf_Run.uvproj, settings and files
target ModulesIf_Run (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ModulesIf_Run
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;..\ModulesIf_Run
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s ModulesIf_Run.cpp
    ./common/: Logger.cpp Logger.h
    ./Interfaces/: IRunnable.h foo.h
    ./IO/: PLL.c PLL.h UART.c UART.h UartAdapter.cpp UartAdapter.h
    ./ModuleA/: ModuleA.cpp ModuleA.h
    ./ModuleB/: ModuleB.cpp ModuleB.h
    ./ModuleC/: ModuleC.cpp ModuleC.h
    ./libs/: suppliers_lib.lib
  group config
    ./config/: module_files.csv module_array_members.csv module_vars.csv
